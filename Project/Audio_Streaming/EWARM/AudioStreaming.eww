<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AudioStreaming.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>USB-Package-AudioStreaming</name>
      <member>
        <project>AudioStreaming</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>AudioStreaming</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>AudioStreaming</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>AudioStreaming</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>AudioStreaming</project>
        <configuration>STM32L152-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


